Commit message: mass change

File: src/ddr_urdf/ddr_urdf.urdf (robot description, URDF)
Before this commit: robot ddr_urdf, 4 links, 3 joints
Links:
- link base_link: mass 0.443722021822356 -> 3
